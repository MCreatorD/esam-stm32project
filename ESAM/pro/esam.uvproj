# Keil uVision project esam.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: esam
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\app\inc;..\lib\inc;..\startup;..\bsp\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/inc/: stm32f10x_conf.h stm32f10x_it.h
    ../app/src/: stm32f10x_it.c main.c
  group lib
    ../lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ../startup/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group bsp
    ../bsp/inc/: debug.c esam.c util.c
    ../bsp/src/: debug.h util.h esam.h
